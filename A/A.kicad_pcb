# Repository boobalakrishnan08/Arty100T (continued)

## KiCad design A/A.kicad_pcb (continued)

Schematic: DDR3_sch.kicad_sch

Parts:
C20, C21, C22, C24, C25, C26, C28, C29, C30, C32, C33, C35, C36, C38, C39, C41, C42, C44, C45: 47nF; C_1206_3216Metric
C23, C27, C31, C34, C37, C40, C43: 100nF; C_1206_3216Metric
C46: 10uF; C_1206_3216Metric
C47: 100nF; C_0201_0603Metric
C48, C49: 10nF; C_0201_0603Metric
R83, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R98, R99, R100, R101, R102, R103, R104, R105, R106, R107: 40.2 1%; R_0402_1005Metric
R97: 4.7K; R_0402_1005Metric
R163: 80.6; R_0402_1005Metric
U3: MT41K128M16JT-125_K; BGA80P96C6X16_800X1400X110

Connections:
DDR3VREF: C47.1, C48.1, C49.2, U3.H1 (VREFDQ), U3.M8 (VREFCA)
DDR3_A0: R105.2, U3.N3 (A0); also elsewhere on the board
DDR3_A1: R104.2, U3.P7 (A1); also elsewhere on the board
DDR3_A2: R103.2, U3.P3 (A2); also elsewhere on the board
DDR3_A3: R102.2, U3.N2 (A3); also elsewhere on the board
DDR3_A4: R101.2, U3.P8 (A4); also elsewhere on the board
DDR3_A5: R100.2, U3.P2 (A5); also elsewhere on the board
DDR3_A6: R99.2, U3.R8 (A6); also elsewhere on the board
DDR3_A7: R98.2, U3.R2 (A7); also elsewhere on the board
DDR3_A8: R96.2, U3.T8 (A8); also elsewhere on the board
DDR3_A9: R95.2, U3.R3 (A9); also elsewhere on the board
DDR3_A10: R94.2, U3.L7 (A10/AP); also elsewhere on the board
DDR3_A11: R93.2, U3.R7 (A11); also elsewhere on the board
DDR3_A12: R92.2, U3.N7 (A12/~BC); also elsewhere on the board
DDR3_A13: R91.2, U3.T3 (A13); also elsewhere on the board
DDR3_BA0: R90.2, U3.M2 (BA0); also elsewhere on the board
DDR3_BA1: R89.2, U3.N8 (BA1); also elsewhere on the board
DDR3_BA2: R88.2, U3.M3 (BA2); also elsewhere on the board
DDR3_CAS: R84.2, U3.K3 (~CAS); also elsewhere on the board
DDR3_CKE0: R87.2, U3.K9 (CKE); also elsewhere on the board
DDR3_CLK0_N: R163.2, U3.K7 (~CK); also elsewhere on the board
DDR3_CLK0_P: R163.1, U3.J7 (CK); also elsewhere on the board
DDR3_CS: R86.2, U3.L2 (~CS); also elsewhere on the board
DDR3_DM0: U3.E7 (LDM); also elsewhere on the board
DDR3_DM1: U3.D3 (UDM); also elsewhere on the board
DDR3_DQ0: U3.E3 (DQ0); also elsewhere on the board
DDR3_DQ1: U3.F7 (DQ1); also elsewhere on the board
DDR3_DQ2: U3.F2 (DQ2); also elsewhere on the board
DDR3_DQ3: U3.F8 (DQ3); also elsewhere on the board
DDR3_DQ4: U3.H3 (DQ4); also elsewhere on the board
DDR3_DQ5: U3.H8 (DQ5); also elsewhere on the board
DDR3_DQ6: U3.G2 (DQ6); also elsewhere on the board
DDR3_DQ7: U3.H7 (DQ7); also elsewhere on the board
DDR3_DQ8: U3.D7 (DQ8); also elsewhere on the board
DDR3_DQ9: U3.C3 (DQ9); also elsewhere on the board
DDR3_DQ10: U3.C8 (DQ10); also elsewhere on the board
DDR3_DQ11: U3.C2 (DQ11); also elsewhere on the board
DDR3_DQ12: U3.A7 (DQ12); also elsewhere on the board
DDR3_DQ13: U3.A2 (DQ13); also elsewhere on the board
DDR3_DQ14: U3.B8 (DQ14); also elsewhere on the board
DDR3_DQ15: U3.A3 (DQ15); also elsewhere on the board
DDR3_DQS0_N: U3.G3 (~LDQS); also elsewhere on the board
DDR3_DQS0_P: U3.F3 (LDQS); also elsewhere on the board
DDR3_DQS1_N: U3.B7 (~UDQS); also elsewhere on the board
DDR3_DQS1_P: U3.C7 (UDQS); also elsewhere on the board
DDR3_ODT: R107.1, U3.K1 (ODT); also elsewhere on the board
DDR3_RAS: R85.2, U3.J3 (~RAS); also elsewhere on the board
DDR3_RESET: R97.1, U3.T2 (~RESET); also elsewhere on the board
DDR3_WE: R83.2, U3.L3 (~WE); also elsewhere on the board
DDRVCC: C20.1, C21.1, C22.1, C24.1, C25.1, C26.1, C28.1, C29.1, C30.1, C32.1, C33.1, C35.1, C36.1, C38.1, C39.1, C41.1, C42.1, C44.1, C45.1, C49.1, U3.A1 (VDDQ), U3.A8 (VDDQ), U3.B2 (VDD), U3.C1 (VDDQ), U3.C9 (VDDQ), U3.D2 (VDDQ), U3.D9 (VDD), U3.E9 (VDDQ), U3.F1 (VDDQ), U3.G7 (VDD), U3.H2 (VDDQ), U3.H9 (VDDQ), U3.K2 (VDD), U3.K8 (VDD), U3.N1 (VDD), U3.N9 (VDD), U3.R1 (VDD), U3.R9 (VDD); also elsewhere on the board
DDRVTT: C23.1, C27.1, C31.1, C34.1, C37.1, C40.1, C43.1, C46.1, R83.1, R84.1, R85.1, R86.1, R87.1, R88.1, R89.1, R90.1, R91.1, R92.1, R93.1, R94.1, R95.1, R96.1, R98.1, R99.1, R100.1, R101.1, R102.1, R103.1, R104.1, R105.1, R107.2
GND: C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, R97.2, R106.1, U3.A9 (VSS), U3.B1 (VSSQ), U3.B3 (VSS), U3.B9 (VSSQ), U3.D1 (VSSQ), U3.D8 (VSSQ), U3.E1 (VSS), U3.E2 (VSSQ), U3.E8 (VSSQ), U3.F9 (VSSQ), U3.G1 (VSSQ), U3.G8 (VSS), U3.G9 (VSSQ), U3.J2 (VSS), U3.J8 (VSS), U3.M1 (VSS), U3.M9 (VSS), U3.P1 (VSS), U3.P9 (VSS), U3.T1 (VSS), U3.T9 (VSS); also elsewhere on the board
unnamed: R106.2, U3.L8 (ZQ)

Board: 2 copper layers, 586 parts (0 on the bottom side), 476 nets, no tracks yet.
